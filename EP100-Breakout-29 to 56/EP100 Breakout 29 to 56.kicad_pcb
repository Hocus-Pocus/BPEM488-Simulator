# Repository Hocus-Pocus/BPEM488-Simulator

File README.md:

# BPEM488-Simulator
Simulator hardware for the BPEM488 engine controller project

## KiCad design EP100-Breakout-29 to 56/EP100 Breakout 29 to 56.kicad_pcb

Parts:
BT1: CR2032 3V
C1, C2: 10uF
C6: 0.001uF
C9, C10: 33uF
C11: 22pF
C12, C13: 0.1uF
D1, D2, D10, D11: Red
D3, D7, D9: Grn
D4, D6: 1N4001
D5: 22V 1W
D8: Yel
IC1, IC2: 4N25; DIP6
K1, K2, K3: CONN_3
L1: 1uH
P1: CONN_2
P2: CONN_11X2
Q1, Q2, Q3, Q4, Q5: ZTX450; TO92
R1, R10, R11, R13, R14, R23, R27, R28, R31: 2.4k
R2, R4, R5, R6, R7, R8, R9, R12, R15, R19, R20, R21, R22, R24, R26, R29, R30, R32: 1k
R3, R16, R33: 100k
R18: 10k
R25: 1.5k
SC1: AMP_10100708_SD-MMC
SW1, SW2: SPST
SW4, SW5, SW6: 6MM-TACT_SW
U1: HEF4050B
U2: LM1117-3.3/NOPB
U6: R-78B5.0-1.0
U7: DS3234

Connections:
+12V: C9.1, D4.2 (K), D5.2 (K), D6.2 (K), D8.1 (A), K1.3, K2.3, K3.3, R1.1, R10.1, R14.1, R28.1, R31.1, U6.1 (+Vin)
/PB5: P2.1, R2.1
/PB6: P2.2, R32.1
/PB7: P2.3, R15.1
/PE0: D3.1 (A), P2.19, Q3.1 (E), R11.2, R13.1
/PE1: D7.1 (A), P2.18, Q4.1 (E), R23.1, R27.2
/PE2: P2.17, R6.1, SC1.CD (Card_Detect)
/PE3: P2.16, R22.2
/PE4: P2.11, R9.2
/PE5: P2.10, R20.2
/PE6: P2.9, R5.2
/PE7: P2.8, R30.2
/PH0: P2.15, SC1.7 (Data_Out)
/PH1: P2.14, U1.5 (2A)
/PH2: P2.13, U1.3 (1A), U1.9 (4A)
/PH3: P2.12, U1.7 (3A)
/PH4: P2.7, U7.19 (Dout)
/PH5: P2.6, U7.17 (Din)
/PH6: P2.5, U7.18 (SCLK), U7.20 (SCLK)
/PH7: P2.4, U7.1 (CS)
GND: BT1.2 (-), C1.2, C2.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.2, D5.1 (A), K1.1, K2.1, K3.1, P1.2 (PM), P2.21, Q1.1 (E), Q2.1 (E), Q5.1 (E), R3.1, R11.1, R12.1, R16.1, R24.1, R25.1, R26.1, R27.1, R33.1, SC1.3 (VSS1), SC1.6 (VSS2), SW1.2, SW2.2, SW4.3, SW5.3, SW6.3, U1.8 (VSS), U1.11 (5A), U1.14 (6A), U2.1 (Gnd), U6.2 (GND), U7.2 (Gnd), U7.7 (Gnd), U7.8 (Gnd), U7.9 (Gnd), U7.10 (Gnd), U7.11 (Gnd), U7.12 (Gnd), U7.13 (Gnd), U7.14 (Gnd), U7.15 (Gnd)
unnamed: D9.2 (K), R26.2
unnamed: D8.2 (K), R25.2
unnamed: D10.1 (A), R31.2
unnamed: D10.2 (K), Q5.2 (C)
unnamed: Q5.3 (B), R32.2, R33.2
unnamed: IC1.2, K1.2 (PM)
unnamed: BT1.1 (+), U7.16 (Vbat)
unnamed: R21.1, R22.1, SW5.1
unnamed: IC2.2, K2.2 (PM)
unnamed: R18.1, U7.5 (INT/SQW)
unnamed: D7.2 (K), R24.2
unnamed: IC1.4, Q3.3 (B), R13.2
unnamed: IC1.1, R10.2
unnamed: IC2.4, Q4.3 (B), R23.2
unnamed: IC2.1, R28.2
unnamed: D1.1 (A), R1.2
unnamed: D1.2 (K), Q1.2 (C)
unnamed: Q1.3 (B), R2.2, R3.2
unnamed: D3.2 (K), R12.2
unnamed: D2.1 (A), R14.2
unnamed: D2.2 (K), Q2.2 (C)
unnamed: Q2.3 (B), R15.2, R16.2
unnamed: R8.1, R9.1, SW2.1
unnamed: R4.1, R5.1, SW1.1
unnamed: D11.1 (A), U1.10 (4Y)
unnamed: C2.1, SC1.4 (VDD), U1.1 (VDD), U2.2 (Vout)
unnamed: SC1.5 (CLK), U1.2 (1Y)
unnamed: SC1.2 (CMD), U1.4 (2Y)
unnamed: R29.1, R30.1, SW6.1
unnamed: R19.1, R20.1, SW4.1
unnamed: R7.2, SC1.1 (CD), U1.6 (3Y)
unnamed: D11.2 (K), R7.1
unnamed: C6.1, D4.1 (A), P1.1
unnamed: C10.1, C12.1, D6.1 (A), L1.2, U6.3 (+Vout)
VDD: C1.1, C11.1, C13.1, D9.1 (A), IC1.5, IC2.5, K3.2 (PM), L1.1, P2.20, Q3.2 (C), Q4.2 (C), R4.2, R6.2, R8.2, R18.2, R19.2, R21.2, R29.2, U2.3 (Vin), U7.4 (VCC)

Notes on the sheet:
3.3V regulator
5V-3.3V Level Shifters
MISO1
MOSI1
SCK1
SS1
IRQ
XIRQ
Battery +
Battery -
Fused
Pwr
Sig
Gnd
To hall effect gear tooth sensor
12V
NPN open collector
SS2
MOSI2
SCK2
MISO2
Real Time Clock
SCK
MISO
MOSI
Card detect grounds pin when card is inserted

Board: 2 copper layers, 87.6 x 99.7 mm, 79 parts (0 on the bottom side), 56 nets.

Other parts of the board:
Hole .125, Hole .125#2, Hole .125#3, Hole .125#4: P***; Hole.125

## Commit log

2022-11-15 Create test file
2022-11-15 Create Git Hold
